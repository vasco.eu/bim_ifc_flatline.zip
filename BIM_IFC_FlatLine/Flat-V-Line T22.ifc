Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2018-11-16T09:02:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.0.1185.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 16 09:02:30 2018 * Host: ZZ010968 * Database: C:\Users\YARINM~1\AppData\Local\Temp\{703297B4-001C-46F4-BDE2-F3A840B7AE6B}\ifc * Database version: 5507 * Database creation date: Fri Nov 16 09:02:27 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 16 09:02:28 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 16 09:02:28 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Kit de vanne - Arrêt aveugle (3)
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Arrêt aveugle
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Arrêt aveugle
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Arrêt aveugle
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.00148457 m2; Volume: 0.0000116913 m3
Other - Family: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Family and Type: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Type: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Type Id: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle
Phasing - Phase Created: New Construction
Name (Kit de vanne - Arrêt aveugle:Kit de vanne - Arrêt aveugle:...) | Offset (mm) | Mark
316299 | 1760 | 3
316301 | 140 | 5
316302 | 140 | 6

# IfcBuildingElementProxy: Kit de vanne - Bloc 50mm, Kit de vanne - Bloc 50mm:Kit de vanne - Bloc 50mm:316298
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Bloc 50mm
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Bloc 50mm
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Bloc 50mm
Constraints - Level: Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no; Offset: 121.75 mm
Dimensions - Area: 0.0168873 m2; Volume: 0.000149621 m3
Identity Data - Mark: 2
Other - Family: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Family and Type: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Type: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Type Id: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Kit de vanne - Purgeur, Kit de vanne - Purgeur:Kit de vanne - Purgeur:316300
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Purgeur
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Purgeur
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Purgeur
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset: 1760 mm
Dimensions - Area: 0.00203434 m2; Volume: 0.0000140474 m3
Identity Data - Mark: 4
Other - Family: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Family and Type: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Type: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Type Id: Kit de vanne - Purgeur: Kit de vanne - Purgeur
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: T22_400_1600, Flat-V-Line T22:T22_400_1600:316297
In: Level 1
Type - Material: White Fine Texture
Type - Dimensions - épaisseur: 108 mm; hauteur: 1600 mm; hauteur_01: 1540 mm; largeur: 400 mm; largeur_02: 328 mm; Offset: 1760 mm; Offset_01: 140 mm; Offset_02: 121.8 mm
Type - Energy Analysis - émission_chauffage: 13788.6
Type - General - débit_r01: 0 m3/s; débit_r02: 0 m3/s; diamètre_r01: 30 mm; diamètre_r02: 30 mm
Type - Identity Data - Description: Flat-V-Line T22; Manufacturer: Vasco; Model: Flat-V-Line; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: T22_400_1600; URL: https://vasco.eu/nl-nl/flat-v-line
Type - Materials and Finishes - clause de non-responsabilité: Les couleurs peuvent diverger des couleurs affichées à l'écran. Pour les couleurs exactes, veuillez utiliser le nuancier de Vasco.; couleur RAL/RVB: 9016; disponible: White Fine Texture; matière: White Fine Texture; Nom de couleur: White Fine Texture
Type - Mechanical - puissance: 13788.6; rac 1_angle hor: 90 deg; rac 1_angle ver: 0 deg; rac 1_pos x: 225 mm; rac 1_pos y: 48.6 mm; rac 1_pos z: 121.8 mm; rac 2_angle hor: 90 deg; rac 2_angle ver: 0 deg; rac 2_pos x: 225 mm; rac 2_pos y: 48.6 mm; rac 2_pos z: 121.8 mm
Type - Mechanical - Flow - delta_T: 10; facteur_delta_T: 50; température_ambiance: 20 kg/K/s3; température de départ: 75 kg/K/s3; température de retour: 65 kg/K/s3
Type - Other - Category: Mechanical Equipment; code_ETIM: EC011023; code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011023&classVersion=4; Family Name: Flat-V-Line T22; nombre: 6; Position 1: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Position 4: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Position 5: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Position 8: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Position MM: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm
Type - Text - Poids: 39.864
Pset_BuildingElementProxyCommon - Reference: T22_400_1600
Pset_ManufacturerTypeInformation - Manufacturer: Vasco
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.856 m2; Volume: 0.06912 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Supply,Hydronic Return
Other - Family: Flat-V-Line T22: T22_400_1600; Family and Type: Flat-V-Line T22: T22_400_1600; Type: Flat-V-Line T22: T22_400_1600; Type Id: Flat-V-Line T22: T22_400_1600
Phasing - Phase Created: New Construction

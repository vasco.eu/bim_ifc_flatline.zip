Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2018-11-15T12:06:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.0.1185.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 15 12:06:39 2018 * Host: ZZ010968 * Database: C:\Users\YARINM~1\AppData\Local\Temp\{8C63F2DF-7775-4A98-95DB-3A62814CC01B}\ifc * Database version: 5507 * Database creation date: Thu Nov 15 12:06:38 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 15 12:06:38 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 15 12:06:38 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Kit de vanne - Arrêt aveugle (2)
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Arrêt aveugle
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Arrêt aveugle
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Arrêt aveugle
Constraints - Level: Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no; Offset: 170 mm
Dimensions - Area: 0.00148457 m2; Volume: 0.0000116913 m3
Other - Family: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Family and Type: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Type: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Type Id: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle
Phasing - Phase Created: New Construction
Name (Kit de vanne - Arrêt aveugle:Kit de vanne - Arrêt aveugle:...) | Mark
314414 | 2
314415 | 3

# IfcBuildingElementProxy: Kit de vanne - Bloc 50mm (2)
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Bloc 50mm
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Bloc 50mm
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Bloc 50mm
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1; Offset: 121.75 mm
Dimensions - Area: 0.0168873 m2; Volume: 0.000149621 m3
Other - Family: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Family and Type: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Type: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Type Id: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm
Phasing - Phase Created: New Construction
Name (Kit de vanne - Bloc 50mm:Kit de vanne - Bloc 50mm:...) | Mark
314418 | 6
314419 | 7

# IfcBuildingElementProxy: Kit de vanne - Purgeur, Kit de vanne - Purgeur:Kit de vanne - Purgeur:314416
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Purgeur
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Purgeur
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Purgeur
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset: 520 mm
Dimensions - Area: 0.00203434 m2; Volume: 0.0000140474 m3
Identity Data - Mark: 4
Other - Family: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Family and Type: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Type: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Type Id: Kit de vanne - Purgeur: Kit de vanne - Purgeur
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Kit de vanne - Robinet, Kit de vanne - Robinet:Kit de vanne - Robinet:314417
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Kit de vanne - Robinet
Type - Other - Category: Mechanical Equipment; Family Name: Kit de vanne - Robinet
Pset_BuildingElementProxyCommon - Reference: Kit de vanne - Robinet
Constraints - Moves With Nearby Elements: no; Host: Level : Level 1; Level: Level: Level 1; Offset: 520 mm
Dimensions - Area: 0.00970327 m2; Volume: 0.000111425 m3
Identity Data - Mark: 5
Other - Family: Kit de vanne - Robinet: Kit de vanne - Robinet; Family and Type: Kit de vanne - Robinet: Kit de vanne - Robinet; Type: Kit de vanne - Robinet: Kit de vanne - Robinet; Type Id: Kit de vanne - Robinet: Kit de vanne - Robinet
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: T21S_400_400_8-G, Flatline T21S:T21S_400_400_8-G:314413
In: Level 1
Type - Material: White Fine Texture
Type - Dimensions - épaisseur: 69 mm; hauteur: 400 mm; hauteur_01: 390 mm; largeur: 400 mm; Offset: 520 mm; Offset_01: 170 mm
Type - Energy Analysis - émission_chauffage: 3939.59
Type - General - débit_r01: 0 m3/s; débit_r02: 0 m3/s; diamètre_r01: 0 mm; diamètre_r02: 0 mm
Type - Identity Data - Description: Flatline T21S; Manufacturer: Vasco; Model: Flatline; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: T21S_400_400_8-G; URL: https://vasco.eu/nl-nl/radiatoren/horizontal-designradiators/flatline
Type - Materials and Finishes - clause de non-responsabilité: Les couleurs peuvent diverger des couleurs affichées à l'écran. Pour les couleurs exactes, veuillez utiliser le nuancier de Vasco.; couleur RAL/RVB: 9016; disponible: White Fine Texture; matière: White Fine Texture; Nom de couleur: White Fine Texture
Type - Mechanical - puissance: 3939.59; rac 1_angle hor: 90 deg; rac 1_angle ver: 0 deg; rac 1_pos x: 315 mm; rac 1_pos y: 38.9 mm; rac 1_pos z: 121.8 mm; rac 2_angle hor: 90 deg; rac 2_angle ver: 0 deg; rac 2_pos x: 35 mm; rac 2_pos y: 38.9 mm; rac 2_pos z: 121.8 mm
Type - Mechanical - Flow - delta_T: 10; facteur_delta_T: 50; température_ambiance: 20 kg/K/s3; température de départ: 75 kg/K/s3; température de retour: 65 kg/K/s3
Type - Other - Category: Mechanical Equipment; code_ETIM: EC011023; code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011023&classVersion=4; Family Name: Flatline T21S; nombre: 1; nombre_01: 14; Position 2: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Position 3: Kit de vanne - Purgeur: Kit de vanne - Purgeur; Position 6: Kit de vanne - Robinet: Kit de vanne - Robinet; Position 7: Kit de vanne - Arrêt aveugle: Kit de vanne - Arrêt aveugle; Position 8: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm; Position MM: Kit de vanne - Bloc 50mm: Kit de vanne - Bloc 50mm
Type - Text - Poids: 8.53
Pset_BuildingElementProxyCommon - Reference: T21S_400_400_8-G
Pset_ManufacturerTypeInformation - Manufacturer: Vasco
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.2152 m2; Volume: 0.01104 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Supply,Hydronic Return
Other - Family: Flatline T21S: T21S_400_400_8-G; Family and Type: Flatline T21S: T21S_400_400_8-G; Type: Flatline T21S: T21S_400_400_8-G; Type Id: Flatline T21S: T21S_400_400_8-G
Phasing - Phase Created: New Construction
